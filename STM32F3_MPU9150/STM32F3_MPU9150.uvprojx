# Keil uVision project STM32F3_MPU9150.uvprojx, settings and files
target Main Target (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F3_MPU9150
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source\main\src;.\Source\main\inc;.\Source\VirtualCOMport\src;.\Source\VirtualCOMport\inc;.\Source\USBLib\src;.\Source\USBLib\inc;.\Source\CMSIS;.\Source\SPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Main
    ./Source/main/src/: main.c stm32_it.c
    ./Source/main/inc/: platform_config.h stm32_it.h stm32f30x_conf.h
  group Virtual-COM port
    ./Source/VirtualCOMport/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ./Source/VirtualCOMport/inc/: hw_config.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group USB Lib
    ./Source/USBLib/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group CMSIS
    ./Source/CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f30x.h stm32f30x_conf.h system_stm32f30x.c system_stm32f30x.h
  group SPL
    ./Source/SPL/: stm32f30x_adc.c stm32f30x_adc.h stm32f30x_can.c stm32f30x_can.h stm32f30x_comp.c stm32f30x_comp.h stm32f30x_crc.c stm32f30x_crc.h stm32f30x_dac.c stm32f30x_dac.h stm32f30x_dbgmcu.c stm32f30x_dbgmcu.h stm32f30x_dma.c stm32f30x_dma.h stm32f30x_exti.c stm32f30x_exti.h stm32f30x_flash.c stm32f30x_flash.h stm32f30x_gpio.c stm32f30x_gpio.h stm32f30x_i2c.c stm32f30x_i2c.h stm32f30x_iwdg.c stm32f30x_iwdg.h stm32f30x_misc.c stm32f30x_misc.h stm32f30x_opamp.c stm32f30x_opamp.h stm32f30x_pwr.c stm32f30x_pwr.h stm32f30x_rcc.c stm32f30x_rcc.h stm32f30x_rtc.c stm32f30x_rtc.h stm32f30x_spi.c stm32f30x_spi.h stm32f30x_syscfg.c stm32f30x_syscfg.h stm32f30x_tim.c stm32f30x_tim.h stm32f30x_usart.c stm32f30x_usart.h stm32f30x_wwdg.c stm32f30x_wwdg.h
